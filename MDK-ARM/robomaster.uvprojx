# Keil uVision project robomaster.uvprojx, settings and files
target robomaster (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: robomaster +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c misc: --diag_suppress=111,1,550,1215,161,177,188,223
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;..\Application;..\Application\chassis;..\Application\cmd;..\Application\dart;..\Application\gimbal;..\Application\shoot;..\Middlewares\Third_Party\SEGGER\RTT;..\Bsp\adc;..\Bsp\bsp_legacy_support;..\Bsp\can;..\Bsp\dwt;..\Bsp\gpio;..\Bsp\iic;..\Bsp\log;..\Bsp\pwm;..\Bsp\spi;..\Bsp\usart;..\Bsp\usb;..\Modules\algorithm;..\Modules\bluetooth;..\Modules\bmi088;..\Modules\buzzer;..\Modules\can_comm;..\Modules\daemon;..\Modules\imu;..\Modules\ist8310;..\Modules\led;..\Modules\mini_pc;..\Modules\vofa;..\Modules\TFminiPlus;..\Modules\super_cap;..\Modules\remote;..\Modules\referee;..\Modules\oled;..\Modules\msg_center;..\Modules\motor;..\Modules\motor\DJImotor;..\Modules\motor\MImotor;..\Modules\motor\servo_motor;..\Middlewares\Third_Party\SEGGER\Config;..\Application\dart;..\Application;..\Bsp;..\Modules
  asm include: ../Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c crc.c dac.c dma.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
  group Application/Dart
    ../Application/dart/: dart.c
  group Application/Motor
    ../Application/: robot.c
    ../Modules/motor/MImotor/: cybergear.c
  group Modules
    ../Modules/motor/: motor_task.c
    ../Modules/motor/DJImotor/: dji_motor.c
    ../Modules/motor/servo_motor/: servo_motor.c
    ../Modules/algorithm/: controller.c crc8.c crc16.c kalman_filter.c QuaternionEKF.c user_lib.c
    ../Modules/bluetooth/: HC05.c
    ../Modules/bmi088/: bmi088.c
    ../Modules/buzzer/: buzzer.c
    ../Modules/can_comm/: can_comm.c
    ../Modules/daemon/: daemon.c
    ../Modules/imu/: BMI088driver.c BMI088Middleware.c ins_task.c
    ../Modules/ist8310/: ist8310.c
    ../Modules/led/: led_task.c
    ../Modules/mini_pc/: master_process.c seasky_protocol.c
    ../Modules/msg_center/: message_center.c
    ../Modules/oled/: oled.c
    ../Modules/referee/: crc_ref.c referee_task.c referee_UI.c rm_referee.c
    ../Modules/remote/: remote_control.c
    ../Modules/super_cap/: super_cap.c
    ../Modules/TFminiPlus/: tfminiplus.c
    ../Modules/vofa/: vofa.c
  group Middlewares/Third_Party
    ../Middlewares/Third_Party/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Middlewares/Third_Party/SEGGER/Config/: SEGGER_RTT_Conf.h
  group BSP
    ../Bsp/adc/: bsp_adc.c
    ../Bsp/bsp_legacy_support/: bsp_buzzer.c bsp_led.c bsp_temperature.c
    ../Bsp/can/: bsp_can.c
    ../Bsp/dwt/: bsp_dwt.c
    ../Bsp/gpio/: bsp_gpio.c
    ../Bsp/iic/: bsp_iic.c
    ../Bsp/log/: bsp_log.c
    ../Bsp/pwm/: bsp_pwm.c
    ../Bsp/spi/: bsp_spi.c
    ../Bsp/usart/: bsp_usart.c
    ../Bsp/usb/: bsp_usb.c
    ../Bsp/: bsp_init.c
software components: CMSIS:CORE 4.3.0
