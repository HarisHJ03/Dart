# Keil uVision project engineering.uvprojx, settings and files
target ENGINEER (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: engineering +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__FPU_PRESENT=1,USE_USB_OTG_FS,__TARGET_FPU_VFP,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\include;..\USER;..\FWLIB\inc;..\FWLIB\src;..\FUNTION;..\CORE;..\.vscode;..\User_Config;..\Bsp_Device;..\Control_Funtion;..\Task;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\portable\MemMang;..\FreeRTOS\include;..\FreeRTOS;..\PROTOCOL;..\USB_LIB\STM32_USB_Device_Library\Core\inc;..\USB_LIB\STM32_USB_Device_Library\Class\cdc\inc;..\USB_LIB\STM32_USB_OTG_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c arm_cortexM4lf_math.lib usbd_usr.c usbd_desc.c
  group CORE
    ../CORE/: startup_stm32f407xx.s core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User_Config
    ../User_Config/: gpio.c gpio.h can.c can.h usart.c usart.h Delay.c Delay.h Timer.c Timer.h
  group Bsp_Device
    ../Bsp_Device/: bsp_can.c bsp_can.h bsp_usb.c bsp_usb.h
  group Control_Funtion
    ../Control_Funtion/: pid.c pid.h
  group Task
    ../Task/: Start_Task.c Start_Task.h pc_task.c pc_task.h
  group PROTOCOL
    ../PROTOCOL/: pc_rx_data.c pc_rx_data.h pc_tx_data.c pc_tx_data.h data_packet.c data_packet.h protocol.c protocol.h data_fifo.c
  group USB_CDC
    ../USB_LIB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../USB_LIB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd_int.c usb_dcd.c
    ../USB_LIB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
